options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_tx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: URI
  id: variable
  parameters:
    value: '"192.168.2.2"'
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '2412000000'
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '15000'
    value: '1000'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: pdu_length
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 10e6
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["4 MHz", "5 MHz", "6 MHz"]'
    num_opts: '0'
    options: '[4e7, 5e7, 6e7]'
    type: int
    value: '50000000'
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5000000, 10000000, 200000000]'
    type: real
    value: '5000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:5555"'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {state: disabled}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    seed: '0'
    type: int
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_2
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_3
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_4
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_5
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_6
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_int_to_float_1
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join("x" for i in range(pdu_length)))
    period: interval
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    minoutbuf: '100000'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.75'
    mintime: '500'
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_tagged_file_sink_1
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_sink_x_1
  id: blocks_vector_sink_x
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_sink_x_2
  id: blocks_vector_sink_x
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: (0,)
  states: {}
- name: digital_packet_sink_0
  id: digital_packet_sink
  parameters:
    threshold: '-1'
  states: {state: disabled}
- name: digital_packet_sink_1
  id: digital_packet_sink
  parameters:
    threshold: '-1'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, max_msgs=1000000.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='MessageGatekeeper',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              self.msg_count = 0.0
              self.max_msgs = max_msgs  # Set the maximum number of messages to send


          def handle_msg(self, msg):
              if self.msg_count < self.max_msgs:
                  self.message_port_pub(pmt.intern("out"), msg)
                  self.msg_count += 1.0
    max_msgs: '1000000000'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.01'
    minoutbuf: out_buf_size
    pad_front: '100'
    pad_tail: '1000'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 255]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: iio_device_sink_0
  id: iio_device_sink
  parameters:
    buffer_size: '32768'
    channels: '[]'
    cyclic: 'False'
    interpolation: '1'
    params: '[]'
    uri: URI
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: URI
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: URI
  states: {state: disabled}
- name: iio_pluto_sink_1
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {state: disabled}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '5555'
    type: byte
  states: {state: disabled}
- name: network_tcp_sink_1
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '2000'
    type: complex
  states: {state: disabled}
- name: network_tcp_sink_2
  id: network_tcp_sink
  parameters:
    addr: ''
    mode: '1'
    port: '2000'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_2
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '14'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {state: disabled}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {state: disabled}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {state: disabled}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    center_freq0: freq
    devname: uhd
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: packet_len
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: pluto
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters: {}
  states: {state: disabled}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.LS
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: '0.56'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: zmq_address
    timeout: '100'
  states: {state: disabled}
- name: zeromq_pub_msg_sink_1
  id: zeromq_pub_msg_sink
  parameters:
    address: zmq_address
    timeout: '100'
  states: {state: disabled}
- name: zeromq_pub_msg_sink_2
  id: zeromq_pub_msg_sink
  parameters:
    address: zmq_address
    timeout: '100'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_address
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: zmq_address
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_complex_to_float_2, '0', audio_sink_0, '0']
- [blocks_complex_to_float_4, '0', blocks_float_to_short_1, '0']
- [blocks_complex_to_float_5, '0', digital_packet_sink_1, '0']
- [blocks_complex_to_float_6, '0', audio_sink_1, '0']
- [blocks_complex_to_interleaved_char_0, '0', network_tcp_sink_0, '0']
- [blocks_float_to_short_1, '0', iio_device_sink_0, '0']
- [blocks_message_strobe_0_0, strobe, epy_block_0, in]
- [blocks_message_strobe_0_0, strobe, ieee802_11_mac_0, app in]
- [blocks_message_strobe_0_0, strobe, zeromq_pub_msg_sink_1, in]
- [blocks_multiply_const_vxx_0, '0', foo_packet_pad2_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_vector_source_x_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0, '0', wifi_phy_hier_0, '0']
- [epy_block_0, out, zeromq_pub_msg_sink_2, in]
- [foo_packet_pad2_0, '0', blocks_complex_to_float_2, '0']
- [foo_packet_pad2_0, '0', blocks_complex_to_float_4, '0']
- [foo_packet_pad2_0, '0', blocks_complex_to_float_5, '0']
- [foo_packet_pad2_0, '0', blocks_complex_to_float_6, '0']
- [foo_packet_pad2_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [foo_packet_pad2_0, '0', blocks_probe_rate_0, '0']
- [foo_packet_pad2_0, '0', blocks_vector_sink_x_2, '0']
- [foo_packet_pad2_0, '0', iio_pluto_sink_0, '0']
- [foo_packet_pad2_0, '0', network_tcp_sink_1, '0']
- [foo_packet_pad2_0, '0', network_tcp_sink_2, '0']
- [foo_packet_pad2_0, '0', network_udp_sink_0, '0']
- [foo_packet_pad2_0, '0', network_udp_sink_2, '0']
- [foo_packet_pad2_0, '0', osmosdr_sink_0, '0']
- [foo_packet_pad2_0, '0', soapy_plutosdr_sink_0, '0']
- [foo_packet_pad2_0, '0', uhd_usrp_sink_0, '0']
- [foo_packet_pad2_0, '0', zeromq_pub_sink_0, '0']
- [foo_packet_pad2_0, '0', zeromq_pub_sink_1, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [network_socket_pdu_0, pdus, ieee802_11_mac_0, app in]
- [wifi_phy_hier_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
