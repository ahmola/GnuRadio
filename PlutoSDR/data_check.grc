options:
  parameters:
    generate_options: qt_gui
    id: data_check
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/park/workarea/test/test.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PrintData',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=None
              )
              
              self.error_count = 0
              self.ber = 0.0
              

          def work(self, input_items, output_items):
              data = input_items[0]
              
              for d in data:
                  if d < 0 :
                      self.error_count += 1
                      
              self.ber = self.error_count / len(data)
              print(f"bit error rate : {self.ber}")
              print(data)
              
              return len(data)
  states: {}

connections:
- [blocks_file_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
