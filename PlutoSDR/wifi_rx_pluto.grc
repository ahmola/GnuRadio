options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_rx
    output_language: python
  states: {}

blocks:
- name: NumItem
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: URI
  id: variable
  parameters:
    value: '"192.168.2.1"'
  states: {}
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '2484000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz ", "10 MHz", "40 MHz"]'
    num_opts: '0'
    options: '[5000000, 10000000, 40000000]'
    type: real
    value: '40000000'
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: zmq_address1
  id: variable
  parameters:
    value: '"tcp://192.168.45.169:8080"'
  states: {}
- name: zmq_address2
  id: variable
  parameters:
    value: '"tcp://192.168.45.169:8081"'
  states: {}
- name: zmq_mobile1
  id: variable
  parameters:
    value: '"tcp://172.20.10.4:8080"'
  states: {}
- name: zmq_mobile2
  id: variable
  parameters:
    value: '"tcp://172.20.10.4:8081"'
  states: {}
- name: zmq_school1
  id: variable
  parameters:
    value: '"tcp://172.100.15.184:8080"'
  states: {}
- name: zmq_school2
  id: variable
  parameters:
    value: '"tcp://172.100.15.184:8081"'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[120]'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Strobe Generator',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=None
              )
              self.first_run = True
              
          def work(self, input_items, output_items):
              if self.first_run:
          	    self.first_run = False
          	    return 1
          
              payload = ''.join([chr(x) for x in input_items[0] if 0 <= x < 128])
              print(f"Payload: {payload}")
              return 1
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import time
      import os
      import csv
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, num_item=50000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Receiver TimeStamp',   # will show up in GRC
                  in_sig=[np.int8, np.int32, np.int32, np.float32],
                  out_sig=None
              )
              
              self.start_time = None
              self.end_time = None
              self.data_size = 0.0
              self.count = 0
              self.last_index = 0
              self.num_item = num_item
              self.throughput = 0.0
              self.ber = 0.0
              self.packet_loss = 0.0
              self.path = ""
              self.header = ["Throughput (bit per sec)", "Bit Error Rate (%)", "Packet Loss (%)"]

          def work(self, input_items, output_items):
              if len(input_items[0]) != 0 & input_items[2][0] <= self.num_item:
                  self.last_index = input_items[2][0]
                  
                  if self.last_index != 0:
                      milsec, sec = np.modf(time.time())
                      self.start_time = input_items[1][0]
                      self.end_time = int(sec)
                      self.data_size += len(input_items[0])
                      self.count += 1
                      self.packet_loss = (1 - (self.count / self.num_item)) * 100
                      self.ber = (10 ** input_items[3][0]) * 100
                      self.throughput = self.data_size/(self.end_time - self.start_time)
                      
                      # [Throughput(bps), Bit Error Rate(%), Packet Loss(%)]
                      data = [self.throughput, self.ber, self.packet_loss]
                      # text = f"Throughput : {self.throughput} bps, Bit Error Rate : {self.ber} %, Packet Loss = {self.packet_loss} %, Lastest Index = {self.last_index} \n"
                      # print(f"\n {text} \n")
                      
                      self.path = "test.csv"
                      file_exists = os.path.isfile(self.path)
                      lines = []
                      if file_exists:
                          with open(self.path, mode='r', newline='', encoding='utf-8') as file:
                              reader = list(csv.reader(file))
                              rows = sum(1 for row in reader)
                              
                              #if rows == 2:
                              #    lines.append(reader[1])
                              if rows >= 2 and self.count == 1:
                                  for r in reader[1:]:
                                      lines.append(r)
                              elif rows > 2:
                                  for r in reader[1:-1]:
                                      lines.append(r)
                      
                      lines.append(data)
                      
                      with open(self.path, mode="w", newline='',encoding="utf-8") as file:
                          writer = csv.writer(file)
                          writer.writerow(self.header)
                          writer.writerows(lines)
                          
                      if self.last_index == self.num_item:
                          print("\nReceive Perfectly Done!\n")
                          os._exit(0)
              
              return len(input_items[0])
    num_item: NumItem
  states: {}
- name: epy_block_9
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='print Python Block',   # will show up in GRC
                  in_sig=[np.int32, np.int32],
                  out_sig=[np.int32, np.int32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              if input_items[0][0] != 0:
                  output_items[0][:] = input_items[0][0]
                  output_items[1][:] = input_items[1][0]
                  
              return 2
  states: {state: disabled}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: iio_pluto_source_2
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: NumItem
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    len_tag_key: ''
    manual_gain1: '10'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: URI
  states: {}
- name: pdu_pdu_to_stream_x_2
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: pdu_tagged_stream_to_pdu_8
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: ''
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"BER"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: zmq_school1
    timeout: '100'
    type: int
  states: {}
- name: zeromq_pull_source_0_0
  id: zeromq_pull_source
  parameters:
    address: zmq_school2
    timeout: '100'
    type: int
  states: {}
- name: zeromq_sub_msg_source_2
  id: zeromq_sub_msg_source
  parameters:
    address: zmq_address
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: zmq_address
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_source_x_0, '0', fec_ber_bf_0, '0']
- [epy_block_9, '0', epy_block_4, '1']
- [epy_block_9, '1', epy_block_4, '2']
- [fec_ber_bf_0, '0', epy_block_4, '3']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_parse_mac_0, out, pdu_pdu_to_stream_x_2, pdus]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [iio_pluto_source_2, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_2, '0', blocks_delay_0_0, '0']
- [iio_pluto_source_2, '0', blocks_multiply_xx_0, '0']
- [pdu_pdu_to_stream_x_2, '0', epy_block_0, '0']
- [pdu_pdu_to_stream_x_2, '0', epy_block_4, '0']
- [pdu_pdu_to_stream_x_2, '0', fec_ber_bf_0, '1']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [zeromq_pull_source_0, '0', epy_block_4, '1']
- [zeromq_pull_source_0, '0', epy_block_9, '0']
- [zeromq_pull_source_0_0, '0', epy_block_4, '2']
- [zeromq_pull_source_0_0, '0', epy_block_9, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
