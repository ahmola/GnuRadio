options:
  parameters:
    generate_options: qt_gui
    id: zmq_send
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: pdu_length
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:5555"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join("kero " for i in range(pdu_length)))
    period: '1000'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: zmq_address
    timeout: '100'
  states: {}

connections:
- [analog_sig_source_x_0, '0', zeromq_pub_msg_sink_0, in]
- [blocks_message_strobe_0, strobe, zeromq_pub_msg_sink_0, in]

metadata:
  file_format: 1
