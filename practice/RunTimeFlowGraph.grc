options:
  parameters:
    generate_options: qt_gui
    id: sineWaveFlowGraph
    output_language: python
    title: FirstFlowGraph
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_chooser
  parameters:
    label1: 'Frequency: 1000'
    label2: 'Frequency: -2000'
    num_opts: '3'
    option0: '0'
    option1: '1000'
    option2: '-2000'
    type: int
    value: '0'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: samp_rate/3
  states: {state: disabled}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: '100'
    stop: samp_rate/2
    value: '0'
  states: {state: disabled}
- name: frequency_range
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: '100'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency_range
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
